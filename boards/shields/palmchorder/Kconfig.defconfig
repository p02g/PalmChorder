## boards/shields/palmchorder/Kconfig.defconfig
```kconfig
if SHIELD_PALMCHORDER

config ZMK_KEYBOARD_NAME
    default "PalmChorder"

endif # SHIELD_PALMCHORDER
```
